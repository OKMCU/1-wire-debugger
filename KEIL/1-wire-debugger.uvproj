# Keil uVision project 1-wire-debugger.uvproj, settings and files
target 1-wire-debugger (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: 1-wire-debugger +hex
  c include: ..\lib\bufmgr;..\lib\stdlib;..\lib\stringx;..\hal;..\app;..\main;..\osal;..\osal\portable;..\spl;..\spl\fwlib;..\osal\portable\heapmgr
  link misc: REMOVEUNUSED
  group LIB
    ../lib/bufmgr/: bufmgr.c
    ../lib/stringx/: stringx.c
    ../lib/stdlib/: stdstr.c
  group SPL
    ../spl/: STARTUP.A51 spl_mcu.c spl_uart.c spl_interrupt.c spl_adc.c spl_sysclk.c spl_timer.c spl_owbus.c
  group HAL
    ../hal/: hal_assert.c hal_cli.c hal_drivers.c hal_mcu.c hal_key.c hal_oweeprom.c hal_owdev.c
  group OSAL
    ../osal/: osal_fifo.c osal_msg.c osal_system.c osal_task.c osal_timer.c
  group OSAL\PORTABLE
    ../osal/portable/: osal_port.c
  group APP
    ../app/: app_assert.c app_event_main.c app_info.c app_task_main.c app_task_cli.c app_event_cli.c app_task_key.c app_event_key.c
  group MAIN
    ../main/: main.c
